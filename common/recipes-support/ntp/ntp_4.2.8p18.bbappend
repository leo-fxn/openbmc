FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
  file://0001-Cherry-pick-fix-for-https-bugs.ntp.org-show_bug.cgi-.patch \
"
