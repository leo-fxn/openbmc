FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
  file://0001-Implement-Receive-Data-from-NC-Command-0x4D-for-NC-S.patch \
"
