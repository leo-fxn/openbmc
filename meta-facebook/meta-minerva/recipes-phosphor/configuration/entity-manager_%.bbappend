FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-configurations-minerva-change-fan-board-probe-condit.patch \
"
